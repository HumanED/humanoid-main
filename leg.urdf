Commit message: Correcting dimensions

File: leg.urdf (robot description, URDF)
Before this commit: robot humanoid_leg, 7 links, 6 joints
Links:
- link hip2: geometry visual box size=0.05 0.018 0.018; visual cylinder length=0.02 radius=0.016
